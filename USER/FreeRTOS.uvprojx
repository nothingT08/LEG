# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LEG +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\SYSTEM\delay;..\mpu\ComplexMathFunctions;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FWLIB\inc;..\PUBLIC;..\mpu;..\FreeRTOS;.\user_lib;..\HARDWARE\inc;..\RMJudge;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../PUBLIC/: Variable.c
  group HARDWARE
    ../HARDWARE/src/: can received.c can send.c can.c pid.c remote_control.c TaskInit.c usart_dr16.c RS485.c
    ./: LASER.c Kalaman.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_iwdg.c stm32f4xx_spi.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_dac.c stm32f4xx_pwr.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c cmsis_os.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group MPU
    ../mpu/: accelerometer_calibration.c BSP_Flash.c BSP_MPU9250_Init.c Filter_Control.c IMUTask.c mpu_delay.c MPU_SPI_Init.c MPU_TIME_Init.c arm_cortexM4lf_math.lib
  group RMJudge
    ../RMJudge/: Judge_Task.c judgement_info.c protocol.c RM_Client_UI.c
